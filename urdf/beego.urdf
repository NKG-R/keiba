Commit message: FInish black_line

File: urdf/beego.urdf (robot description, URDF)
Before this commit: robot beego, 6 links, 5 joints
Joints:
- joint camera_joint: origin xyz=0.012 0 0.185 rpy=0 0 0 -> xyz=0.012 0 0.05 rpy=0 0 0
